FILESEXTRAPATHS:prepend := "${THISDIR}/imx-boot:"

SRC_URI += " \
    file://0001-arm64-imx8mm-config-DRAM.patch \
"