FILESEXTRAPATHS_prepend := "${THISDIR}/optee-os:"

SRC_URI += " \
    file://0001-arm64-imx8mm-config-DRAM.patch \
"