REQUIRED_DISTRO_FEATURES_mx8:remove = "wayland"
