COMPATIBLE_MACHINE_iesy-imx8m-eva-mi = "iesy-imx8m-eva-mi"
